# Keil uVision project IO_Toggle.uvproj, settings and files
target IO_Toggle (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: skyworksF4 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4
  c include: ..\;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Source\include;..\Source;..\Source\portable;..\Source\portable\MemMang;..\Libraries\FatFs;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c sensor.c diskTask.c buttonTask.c AHRSEKF.c ledTask.c uartTask.c kalman.c axisTrans.c INSEKF.c flightConTask.c filter.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_i2c.c
  group MDK-ARM
    ../StartUp/: startup_stm32f4xx.s
  group FreeRTOS Files
    ../Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/: port.c
  group UserPeriph
    ../User/: UART.c stm324xg_eval.c stm324xg_eval_sdio_sd.c button.c led.c pwm.c ultraSonic.c AHRS.c
  group FatFs
    ../Libraries/FatFs/: ff.c diskio.c
  group arm_DSPlib
    ../Libraries/CMSIS/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_inverse_f32.c arm_mat_sub_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c
    ../Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
